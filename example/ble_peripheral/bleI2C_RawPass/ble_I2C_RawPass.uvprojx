# Keil uVision project ble_I2C_RawPass.uvprojx, settings and files
target ble_IIC (RawPass) Sample (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_I2C_RawPass +hex
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/ble_I2C_RawPass.axf
  AfterMake: fromelf.exe .\Objects\ble_I2C_RawPass.axf --i32combined --output .\bin\ble_I2C_RawPass.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP CFG_QFN32 CFG_SLEEP_MODE=PWR_MODE_SLEEP DEBUG_INFO = 1
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\components\ble\controller\include;..\..\..\components\ble\include;..\..\..\components\ble\host;..\..\..\components\ble\hci;..\..\..\components\common;..\..\..\components\driver\clock;..\..\..\components\driver\common;..\..\..\components\driver\gpio;..\..\..\components\driver\i2c;..\..\..\components\driver\log;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\adc;..\..\..\components\driver\spi;..\..\..\components\driver\flash;..\..\..\components\inc;..\..\..\components\osal\common;..\..\..\components\osal\include;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\Roles;..\..\..\components\profiles\SimpleProfile;..\..\..\components\osal\include;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer;..\..\..\components\driver\kscan;..\..\..\lib;.\Source
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\rom1Sym.txt --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group profile
    ../../../components/profiles/Roles/: gap.c gapbondmgr.c peripheral.c gapgattserver.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../../../components/profiles/DevInfo/: devinfoservice.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: bleIIC_Slave.c bleIIC_Slave_Main.c bleIIC_Slave_protocol.c bleIIC_Slave_service.c OSAL_bleIIC_Slave.c
  group rf
    ../../../lib/: rf.lib
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/common/: common.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/i2c/: i2c_common.c i2c_slave.c
    ../../../components/driver/flash/: flash.c
  group osal
    ../../../components/osal/snv/: osal_snv.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
