# Keil uVision project ota_if.uvprojx, settings and files
target ota_internal_flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ota
  AfterMake: fromelf.exe --bin -o  ./bin  ./Objects/ota.axf
  AfterMake: fromelf.exe .\Objects\ota.axf --i32combined --output .\bin\ota.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP CFG_QFN32 CFG_FLASH=4096 CFG_OTA_BANK_MODE=OTA_DUAL_BANK  USE_FCT=1 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP DEBUG_INFO=1
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: ..\..\..\components\inc;..\..\..\components\common;..\..\..\components\osal\include;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\ble\controller\include;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\GATT;..\..\..\components\profiles\SimpleProfile;..\..\..\components\profiles\Roles;..\..\..\components\profiles\hrs;..\..\..\components\profiles\ota;..\..\..\components\profiles\ota_app;..\..\..\components\libraries\crc16;..\..\..\components\driver\common;..\..\..\components\driver\log;..\..\..\components\driver\gpio;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\clock;..\..\..\components\driver\adc;..\..\..\components\driver\flash;..\..\..\components\driver\kscan;..\..\..\components\driver\i2c;..\..\..\components\driver\spi;..\..\..\lib;.\Source;..\..\..\components\driver\watchdog;..\..\..\components\driver\timer
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\rom1Sym.txt --keep=jump_table_base  --keep=global_config
  group arch
    ./Source/: main.c
  group profile
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../../../components/profiles/Roles/: gap.c gapgattserver.c peripheral.c
    ../../../components/profiles/hrs/: heartrateservice.c
    ../../../components/profiles/ota/: ota_service.c ota_protocol.c ota_flash.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./Source/: OSAL_ota.c ota_Main.c ota.c
  group rf
    ../../../lib/: rf.lib
  group driver
    ../../../components/driver/common/: common.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
  group libraries
    ../../../components/libraries/crc16/: crc16.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
